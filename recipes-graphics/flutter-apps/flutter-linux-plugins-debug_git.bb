include flutter-linux-plugins.inc

FLUTTER_RUNTIME = "debug"

DEPENDS += "\
    flutter-engine-${FLUTTER_RUNTIME} \
    "
