include flutter-gallery.inc

FLUTTER_RUNTIME = "profile"

DEPENDS += "\
    flutter-engine-${FLUTTER_RUNTIME} \
    "
