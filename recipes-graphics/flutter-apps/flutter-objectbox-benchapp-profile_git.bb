include flutter-objectbox-benchapp.inc

FLUTTER_RUNTIME = "profile"

DEPENDS += "\
    flutter-engine-${FLUTTER_RUNTIME} \
    "
