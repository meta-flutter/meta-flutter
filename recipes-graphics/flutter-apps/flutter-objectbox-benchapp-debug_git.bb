include flutter-objectbox-benchapp.inc

FLUTTER_RUNTIME = "debug"

DEPENDS += "\
    flutter-engine-${FLUTTER_RUNTIME} \
    "
