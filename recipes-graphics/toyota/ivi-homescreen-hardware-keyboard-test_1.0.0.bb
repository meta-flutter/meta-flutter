#
# Copyright (c) 2020-2026 Joel Winarske. All rights reserved.
#

SUMMARY = "hardware_keyboard_test"
DESCRIPTION = "Integration test app for HardwareKeyboard against the ivi-homescreen \
embedder API."

require ivi-homescreen-test.inc

PUBSPEC_APPNAME = "hardware_keyboard_test"
