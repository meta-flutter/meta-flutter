require ivi-homescreen.inc

EXTRA_OECMAKE += "\
    -D CMAKE_BUILD_TYPE=Debug \
"
