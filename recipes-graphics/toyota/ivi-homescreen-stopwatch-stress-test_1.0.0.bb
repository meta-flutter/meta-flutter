#
# Copyright (c) 2020-2026 Joel Winarske
#
# SPDX-License-Identifier: MIT
#

SUMMARY = "stopwatch_stress_test"
DESCRIPTION = "Integration test app that runs a stopwatch and spinner while the embedder \
is stressed, exercising the watchdog under load."

require ivi-homescreen-test.inc

PUBSPEC_APPNAME = "stopwatch_stress_test"
