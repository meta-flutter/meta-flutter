require ivi-homescreen.inc

FLUTTER_RUNTIME = "release"

DEPENDS += "flutter-engine-${FLUTTER_RUNTIME}"
