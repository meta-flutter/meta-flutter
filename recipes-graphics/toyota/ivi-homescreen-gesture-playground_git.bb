#
# Copyright (c) 2020-2026 Joel Winarske. All rights reserved.
#

SUMMARY = "gesture_playground"
DESCRIPTION = "Exercises custom map-style gesture recognizers built on Flutter's gesture \
arena, plus a live diagnostic surface for the pointer input stack. Useful \
for validating touch, mouse, trackpad and stylus input on a given embedder \
and backend."

require ivi-homescreen-test.inc

PUBSPEC_APPNAME = "gesture_playground"
