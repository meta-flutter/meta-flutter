#
# Copyright (c) 2020-2026 Joel Winarske. All rights reserved.
#

SUMMARY = "watchdog_test"
DESCRIPTION = "Integration test app for the ivi-homescreen watchdog platform channel."

require ivi-homescreen-test.inc

PUBSPEC_APPNAME = "watchdog_test"
