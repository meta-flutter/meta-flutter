#
# Copyright (c) 2020-2026 Joel Winarske. All rights reserved.
#

SUMMARY = "scroll_bench"
DESCRIPTION = "List-scroll fps benchmark app for the ivi-homescreen software, GL and \
Vulkan backends."

require ivi-homescreen-test.inc

PUBSPEC_APPNAME = "scroll_bench"
