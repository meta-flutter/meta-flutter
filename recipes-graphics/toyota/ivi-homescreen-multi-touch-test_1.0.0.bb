#
# Copyright (c) 2020-2026 Joel Winarske. All rights reserved.
#

SUMMARY = "multi_touch_test"
DESCRIPTION = "Integration test app for 10-finger multi-touch delivery against the \
ivi-homescreen embedder."

require ivi-homescreen-test.inc

PUBSPEC_APPNAME = "multi_touch_test"
