#
# Copyright (c) 2026 Joel Winarske
#
# SPDX-License-Identifier: MIT
#
# Generated by tools/sdk_apps.py. Edit the overrides file, not this.
#

SUMMARY = "platform_view"
DESCRIPTION = "The Flutter SDK's platform_view example application."

PUBSPEC_APPNAME = "platform_view"
FLUTTER_APPLICATION_PATH = "examples/platform_view"

require conf/include/flutter-sdk-app.inc
