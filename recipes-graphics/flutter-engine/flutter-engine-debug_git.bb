require flutter-engine.inc

FLUTTER_RUNTIME = "debug"

RPROVIDES_${PN} = "flutter-engine-${FLUTTER_RUNTIME}"