require flutter-engine.inc

FLUTTER_RUNTIME = "profile"

RPROVIDES_${PN} = "flutter-engine-${FLUTTER_RUNTIME}"