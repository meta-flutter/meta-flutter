require flutter-engine.inc
require flutter-engine-2.10.3.inc

FLUTTER_RUNTIME = "debug"

RPROVIDES_${PN} = "flutter-engine-${FLUTTER_RUNTIME}"
