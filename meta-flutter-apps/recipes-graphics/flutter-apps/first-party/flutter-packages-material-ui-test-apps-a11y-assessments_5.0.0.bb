#
# Copyright (c) 2020-2025 Joel Winarske
#
# SPDX-License-Identifier: MIT
#

SUMMARY = "a11y_assessments"
DESCRIPTION = "A new Flutter project"
AUTHOR = "Google"
HOMEPAGE = "None"
BUGTRACKER = "None"
SECTION = "graphics"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2b36ca50262dc615e560c27654badb26"

SRCREV = "87910ce3c3d45c0aea12b48eefe6303ce8b3b6ea"
SRC_URI = "git://github.com/flutter/packages.git;lfs=1;branch=main;protocol=https"

PUBSPEC_APPNAME = "a11y_assessments"
FLUTTER_APPLICATION_INSTALL_SUFFIX = "flutter-packages-material-ui-test-apps-a11y-assessments"
PUBSPEC_IGNORE_LOCKFILE = "1"
FLUTTER_APPLICATION_PATH = "packages/material_ui/test_apps/a11y_assessments"

inherit flutter-app
