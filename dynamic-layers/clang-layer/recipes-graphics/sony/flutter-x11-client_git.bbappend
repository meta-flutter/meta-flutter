require clang.inc