FLUTTER_RUNTIME = "profile"

SERVICE_EXEC_START_PARAMS = "--start-paused"
