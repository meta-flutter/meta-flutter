PACKAGECONFIG:append = " verbose"
