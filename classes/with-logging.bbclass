PACKAGECONFIG_append = " verbose"
